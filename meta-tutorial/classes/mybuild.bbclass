

addtask build
mybuild_do_build () {
 
  echo "class running mybuild_do_build."
 
}

EXPORT_FUNCTIONS do_build
