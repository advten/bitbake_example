DESCRIPTION = "I am the second recepi"
PR = "r1"

inherit mybuild


  
#python do_mypatch () {
#  bb.note ("runnin mypatch")
#  pyfunc(d) 
#}

#addtask mypatch before do_build
