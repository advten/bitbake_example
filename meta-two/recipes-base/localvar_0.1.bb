DESCRIPTION = "show access to local var"
PR='r1'

LOCALVAR="local var in localvar_0.1.bb"

inherit localvar
